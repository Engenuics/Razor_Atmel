<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>_BSP</name>
    <group>
      <name>Includes</name>
      <file>
        <name>$PROJ_DIR$\..\..\firmware_common\AT91SAM3U4.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\firmware_common\configuration.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\bsp\mpgl2-ehdw-02.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\firmware_common\typedefs.h</name>
      </file>
    </group>
    <group>
      <name>Source</name>
      <file>
        <name>$PROJ_DIR$\..\..\firmware_common\board_cstartup_iar.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\bsp\mpgl2-ehdw-02.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\firmware_common\sam3u2-flash.icf</name>
      </file>
    </group>
  </group>
  <group>
    <name>_CMSIS</name>
    <file>
      <name>$PROJ_DIR$\..\..\firmware_common\cmsis\core_cm3.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\firmware_common\cmsis\core_cm3.h</name>
    </file>
  </group>
  <group>
    <name>_Drivers</name>
    <group>
      <name>Include</name>
      <file>
        <name>$PROJ_DIR$\..\..\firmware_common\drivers\ant.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\firmware_common\drivers\ant_api.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\firmware_common\drivers\antdefines.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\firmware_common\drivers\antmessage.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\firmware_common\drivers\buttons.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\drivers\captouch.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\firmware_common\drivers\exceptions.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\firmware_common\drivers\interrupts.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\drivers\lcd_bitmaps.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\drivers\lcd_NHD-C12864LZ.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\firmware_common\drivers\leds.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\firmware_common\drivers\messaging.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\firmware_common\drivers\sam3u_i2c.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\firmware_common\drivers\sam3u_ssp.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\firmware_common\drivers\sam3u_uart.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\firmware_common\drivers\utilities.h</name>
      </file>
    </group>
    <group>
      <name>Source</name>
      <file>
        <name>$PROJ_DIR$\..\..\firmware_common\drivers\ant.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\firmware_common\drivers\ant_api.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\firmware_common\drivers\buttons.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\drivers\captouch.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\firmware_common\drivers\exceptions.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\firmware_common\drivers\interrupts.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\drivers\lcd_bitmaps.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\drivers\lcd_NHD-C12864LZ.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\firmware_common\drivers\leds.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\firmware_common\drivers\messaging.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\firmware_common\drivers\sam3u_i2c.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\firmware_common\drivers\sam3u_ssp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\firmware_common\drivers\sam3u_uart.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\firmware_common\drivers\utilities.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>_Libraries</name>
    <group>
      <name>bin</name>
      <file>
        <name>$PROJ_DIR$\..\libraries\captouch\bin\libsam3u-32qt-k-8rs-iar.a</name>
      </file>
    </group>
    <group>
      <name>Include</name>
      <file>
        <name>$PROJ_DIR$\..\libraries\captouch\libqtouch.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\libraries\captouch\include\touch_api.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\libraries\captouch\include\touch_qt_config.h</name>
      </file>
    </group>
  </group>
  <group>
    <name>Application</name>
    <group>
      <name>Include</name>
      <file>
        <name>$PROJ_DIR$\..\..\firmware_common\application\debug.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\application\main.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\firmware_common\application\music.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\firmware_common\application\user_app1.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\firmware_common\application\user_app2.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\firmware_common\application\user_app3.h</name>
      </file>
    </group>
    <group>
      <name>Source</name>
      <file>
        <name>$PROJ_DIR$\..\..\firmware_common\application\debug.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\application\main.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\firmware_common\application\user_app1.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\firmware_common\application\user_app2.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\firmware_common\application\user_app3.c</name>
      </file>
    </group>
  </group>
</project>


